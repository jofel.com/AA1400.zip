Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Dryers-Hand-Hair_Jofel_Hand-Dryer-Standard-Futura-220-240V-50-6.ifc
Time: 2019-12-06T06:49:30
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Hand Dryer Standard Futura 220-240V 50/60Hz
ePset_BIMobjectScript - Colour: AA16000 - Polished Stainless Steel; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Hand Dryer Standard Futura 220-240V 50/60Hz; SKU (BO_prodsku): hand_dryer_standard_futura_inox_220-240V_50hz; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Hand dryers; ProductGroup (BO_prodgroup): Standard Futura; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 216; Height (BO_height): 318; Depth (BO_depth): 124; Weight (BO_weight): 3.59; QR (BO_boqrurl): http://bimobject.com/jofel/product/hand_dryer_standard_futura_inox_220-240V_50hz; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/hand_dryer_standard_futura_inox_220-240V_50hz; ProductUrl (BO_producturl): https://jofel.com/en/productos/secadores-de-mano/secamanos-futura-brillo-optico.html?___from_store=es; TechnicalDescription (BO_techcert): https://jofel.com/media/fichas/en/AA16000.pdf; InstructionVideo (BO_youtube): https://jofel.com/en/productos/secadores-de-mano/secamanos-futura-brillo-optico.html?___from_store=es; GtinCode (BO_gtin): 8427950304194; MaterialMain (BO_mainmat): Stainless steel; MaterialSecondary (BO_secmat): ABS; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Dryers (Hand & Hair); BimObjectCategoryCode (BO_bocat_code): sanitary-hand-and-hair-dryers; IfcClassification (BO_ifcclas): Electric Appliance; UnspcCode (BO_unspc): 301815; Uniclass14Code (BO_uniclass_1_4_code): L824; Uniclass14Description (BO_uniclass_1_4_desc): Bathroom, toilet furniture and fittings; Uniclass20Code (BO_uniclass_2_0_code): PR-02-03; Uniclass20Description (BO_uniclass_2_0_desc): Air Dryers; Uniclass2015Code (BO_uniclass2015_code): Pr_40_30_78_05; Uniclass2015Description (BO_uniclass2015_desc): Bathroom furniture; NBSReference (BO_nbs_ref): 02-03; NBSReferenceDescription (BO_nbs_desc): Air Dryers; OmniClassCode (BO_omniclass_code): 23-31 25 15; OmniClassDescription (BO_omniclass_name): Hand Dryers; MasterFormat2014Code (BO_masterformat2014_code): 10 28 13; MasterFormat2014Description (BO_masterformat2014_name): Toilet Accessories; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW
